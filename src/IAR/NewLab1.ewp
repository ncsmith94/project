# IAR project NewLab1.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430FR2533 MSP430FR2533
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TARGET_IS_MSP430FR2633; TARGET_IS_MSP430FR2XX_4XX
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx; ../driverlib
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$/config/lnk430fr2533.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group captivate
    ../captivate/: captivate.h
  group captivate/ADVANCED
    ../captivate/ADVANCED/: CAPT_Slider.h CAPT_EMC.h CAPT_Buttons.h CAPT_Manager.h CAPT_Manager.c
  group captivate/BASE
    ../captivate/BASE/: CAPT_Touch.h CAPT_ISR.c CAPT_HAL.h rom_captivate.h rom_map_captivate.h captivate.r43 CAPT_Type.h
  group captivate/COMM
    ../captivate/COMM/: CAPT_Interface.c CAPT_ByteQueue.h CAPT_PingPongBuffer.h CAPT_Protocol.h CAPT_CommConfig.h CAPT_Interface.h
  group captivate/COMM/Serial_Drivers
    ../captivate/COMM/Serial_Drivers/: I2CSlave_Definitions.h UART.h UART.c UART_Definitions.h I2CSlave.h I2CSlave.c FunctionTimer.c FunctionTimer.h FunctionTimer_Definitions.h
  group captivate_app
    ../captivate_app/: CAPT_BSP.c CAPT_BSP.h CAPT_App.h CAPT_App.c
  group captivate_config
    ../captivate_config/: CAPT_UserConfig.h CAPT_UserConfig.c
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: eusci_b_i2c.h driverlib.h driverlib.r43 sac.h wdt_a.h ecomp.h gpio.h tlv.h mpy32.h sfr.h timer_a.h rom_driverlib.h adc.h sysctl.h eusci_a_spi.h cs.h lcd_e.h crc.h framctl.h pmm.h eusci_b_spi.h rom_map_driverlib.h rtc.h timer_b.h eusci_a_uart.h tri.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: version.h hw_memmap.h
